# IAR project Project.ewp, settings and files
configuration STM32F7_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F756xx; USE_HAL_DRIVER; USE_STM32756G_EVAL; USE_USB_HS; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Gui\STemWin_Addons; ..\Gui\Target; ..\Core\Inc; ..\Config; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32756G_EVAL; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Modules\audio_player\Addons\SpiritDSP_Equalizer; ..\Modules\audio_player\Addons\SpiritDSP_LoudnessControl; ..\Modules\audio_player; ..\Modules\videoplayer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32CubeDemo_STM327x6G-EVAL_V1.4.0.hex
  ILINK.IlinkOutputFile: STM327x6G-EVAL_Demo.out
  ILINK.IlinkIcfFile: stm32f756g.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f756xx.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_menu.c k_module.c k_modules_res.c k_rtc.c k_startup.c k_storage.c main.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c
  group Application/User/Gui/games
    ../Gui/Core/games/: games_win.c
  group Application/User/Gui/gardening_control
    ../Gui/Core/gardening_control/: gardening_control_win.c
  group Application/User/Gui/home_alarme
    ../Gui/Core/home_alarme/: home_alarm_win.c
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Gui/videoplayer
    ../Gui/Core/videoplayer/: video_player_win.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_app.c
  group Application/User/Modules/Audio/Addons
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: GUI_AVI.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_audio.c stm32756g_eval_io.c stm32756g_eval_nor.c stm32756g_eval_sd.c stm32756g_eval_sdram.c stm32756g_eval_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Drivers
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Config/: sd_diskio.c usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM7_IAR.a
  group Middlewares/ST_Widgets
    ../Gui/STemWin_Addons/: STM32756G_EVAL_STemWin_Addons_IAR.a
  group Middlewares/STemWin/Config
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_OS_IAR_ot.a
  group Middlewares/STemWin/OS
    ../Config/: GUI_X_FreeRTOS.c
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
